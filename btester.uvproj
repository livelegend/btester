# Keil uVision project btester.uvproj, settings and files
target btester (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: btester +hex
  c flags: Optim=4 oTime=1
  c include: .\CMSIS\Device\ST\STM32F30x\Include;.\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group main
    ./main/: gpio.c main.c
